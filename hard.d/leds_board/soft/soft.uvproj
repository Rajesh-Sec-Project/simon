# Keil uVision project soft.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Us_Receiver
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_OLIMEX_H103
  c include: .\application\inc;.\services\inc;.\drivers\inc_others;.\drivers\inc_usb_md_cdc;.\drivers\inc_peripherals;.\drivers\inc_peripherals\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./application/src/: main.c
  group Services
    ./services/src/: lib_crc.c serialFrame.c usbComm.c
  group Drivers_others
    ./drivers/src_others/: clock.c
    ./Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group Drivers_Periph
    ./drivers/src_peripherals/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drivers_USB
    ./drivers/src_usb_md_cdc/: hw_config.c otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c stm32f10x_it.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_sil.c
  group Headers
    ./services/inc/: defines.h lib_crc.h serialFrame.h usbComm.h
    ./application/inc/: typesAndConstants.h
